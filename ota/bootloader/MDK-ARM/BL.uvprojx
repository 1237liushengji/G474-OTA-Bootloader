# Keil uVision project BL.uvprojx, settings and files
target G474 (6140000::V6.14::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,USER_VECT_TAB_ADDRESS,VECT_TAB_OFFSET=0x0
  c include: ../Core/Inc;../../../G474/Core/Inc;../../../G474/Drivers/STM32G4xx_HAL_Driver/Inc;../../../G474/Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../../../G474/Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../G474/Drivers/CMSIS/Include
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0xb800
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: bl.sct
  group Bootloader
    ./: startup_stm32g474xx.s
    ../Core/Src/: main.c bl_clock.c bl_can.c bl_flash_if.c bl_crc32.c bl_param.c bl_image.c bl_jump.c bl_isotp.c bl_diag.c bl_uart.c
    ../../../G474/Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../G474/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pwr_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_dma.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_uart.c stm32g4xx_hal_iwdg.c
software components: CMSIS:CORE 5.6.0
